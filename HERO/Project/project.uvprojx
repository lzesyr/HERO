# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --c99
  c include: ..\APP;..\BSP;..\Libraries\inc;..\Libraries\src;..\Libraries\cmsis\Include;..\Libraries\cmsis;..\SYSTEM;..\mpu6050;..\mpu6050\eMPL;..\MPU_Temperature;..\Task
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: main.c stm32f4xx_it.c system.c
  group BSP
    ../BSP/: can1.c can2.c crc.c usart2.c usart4.c usart5.c vision.c pwm.c filter.c kalman_filter.c control.c led.c
  group Task
    ../Task/: chassis.c friction.c gimbal.c Super_Cap.c weapon.c
  group SYSTEM
    ../SYSTEM/: usart.c sys.c
  group MPU6050
    ../mpu6050/: myiic.c mpu6050.c
    ../mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group MPU_Temperature
    ../MPU_Temperature/: temp.c
  group DEVICE/CMSIS
    ../Libraries/Device/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group STM32_StdPeriph
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_syscfg.c stm32f4xx_dac.c
    ../Libraries/startup/: startup_stm32f40xx.s
    ../Libraries/cmsis/: system_stm32f4xx.c
